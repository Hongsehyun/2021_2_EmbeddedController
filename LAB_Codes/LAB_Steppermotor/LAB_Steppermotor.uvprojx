# Keil uVision project LAB_Steppermotor.uvprojx, settings and files
target LAB_Steppermotor (6160000::V6.16::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB_Steppermotor +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group LAB_Steppermotor
    ./: LAB_Steppermotor.c
  group HAL
    ../../Lib/: ecEXTI.c ecEXTI.h ecGPIO.c ecGPIO.h ecPWM.c ecPWM.h ecRCC.c ecRCC.h ecStepper.c ecStepper.h ecSysTick.c ecSysTick.h ecTIM.c ecTIM.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
